# Repository MartinKoma/4-Keys

File README.md:

# 4-Keys
I created a PCB for a "keyboard" with 4 keys with kiCad

## KiCad design 4Keys.kicad_pcb

Parts:
C1, C2: 22p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4, C5, C6: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4: D; D_SOD123_axial
J1: USB_mini_micro_B; USB_miniB_hirose_5S8
K1, K2, K3, K4: KEYSW; Mx_Alps_100
R1, R2: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; SW_SPST_TL3342
U1: ATMEGA32U4; ATmega32U4
X1: XTAL_GND; crystal_FA238-TSX3225

Connections:
/col0: K1.1, K2.1, U1.39 (PF4)
/col1: K3.1, K4.1, U1.38 (PF5)
/row0: D1.1 (K), D3.1 (K), U1.41 (PF0)
/row1: D2.1 (K), D4.1 (K), U1.40 (PF1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.5 (GND), J1.6 (SHIELD), R2.1, SW1.1, U1.5 (UGnd), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), X1.3
unnamed: C1.1, U1.16 (XTAL1), X1.1
unnamed: C2.1, U1.17 (XTAL2), X1.2
unnamed: C8.1, U1.6 (UCap)
unnamed: D1.2 (A), K1.2
unnamed: D2.2 (A), K2.2
unnamed: D3.2 (A), K3.2
unnamed: D4.2 (A), K4.2
unnamed: J1.2 (D-), R3.2
unnamed: J1.3 (D+), R4.2
unnamed: R1.1, SW1.2, U1.13 (~RESET)
unnamed: R2.2, U1.33 (~HWB/PE2)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.1, U1.4 (D+)
VCC: C3.1, C4.1, C5.1, C6.1, C7.1, J1.1 (VUSB), R1.2, U1.2 (UVcc), U1.7 (VBus), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)

Board: 2 copper layers, 73.6 x 42.3 mm, 24 parts (20 on the bottom side), 19 nets.
